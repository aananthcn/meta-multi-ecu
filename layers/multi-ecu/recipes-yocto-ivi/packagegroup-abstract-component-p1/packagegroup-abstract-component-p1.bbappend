RDEPENDS_${PN}_remove += "\
    wayland-ivi-extension \
    "

