# Copyright (C) 2015 Aananth Chellapa Natarajan <aananth.cn@visteon.com>
# Released under the MIT license (see COPYING.MIT for the terms)


IMAGE_FEATURES += " ssh-server-dropbear"

IMAGE_INSTALL_append = " \
"
